Commit message: Trajectory configuration ressolved. Catching Visualization OK.

File: matlab-model/urdf/hubo_minimal_contact.urdf (robot description, URDF)
Before this commit: robot hubo2, 30 links, 29 joints
Joints:
- joint base_joint: origin xyz=0 0 0  -> xyz=0 0 1 
